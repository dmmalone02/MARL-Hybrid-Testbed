options:
  parameters:
    generate_options: no_gui
    id: Integrated_Comms_Rx
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: CP_len
  id: variable
  parameters:
    value: fft_len//4
  states: {}
- name: carrier_list
  id: variable
  parameters:
    value: (list(range(-12, -2)))
  states: {}
- name: carrier_list_rf
  id: variable
  parameters:
    value: (list(range(-7, -2)) + list(range(3, 8)))
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: filename
  id: variable
  parameters:
    value: '"/home/ucanlab/Mission_Leader/Sensing_Files/Ep"'
  states: {}
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: header_ph
  id: variable
  parameters:
    value: digital.packet_header_ofdm(occupied_carriers, 1, len_tag_key, "frame_"+len_tag_key, bits_per_header_sym=header_mod.bits_per_symbol(), bits_per_payload_sym=payload_mod.bits_per_symbol(), scramble_header=False)
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (carrier_list,)
  states: {}
- name: occupied_carriers_rf
  id: variable
  parameters:
    value: ((carrier_list_rf),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '18'
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_qpsk()
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-28, -1),)
  states: {}
- name: pilot_carriers_rf
  id: variable
  parameters:
    value: ((-10,-2,2,10),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((-1, 1,),)
  states: {}
- name: pilot_syms_rf
  id: variable
  parameters:
    value: ((-1,1,-1,1),)
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: filename
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: digital_ofdm_rx_0_0
  id: digital_ofdm_rx
  parameters:
    cp_len: CP_len
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: occupied_carriers_rf
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: pilot_carriers_rf
    pilot_symbols: pilot_syms_rf
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: node_id
  id: parameter
  parameters:
    label: Node Number
    short_id: n
    type: str
    value: '100'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: packet_len*10
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 915e6
    dev_args: '""'
    gain0: '70'
    samp_rate: 1e6
    sync: none
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: '"10.1.1." + node_id'
    port: '8080'
  states: {}

connections:
- [blocks_tag_gate_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_ofdm_rx_0_0, '0', blocks_file_sink_0_0, '0']
- [digital_ofdm_rx_0_0, '0', blocks_tag_gate_0_0, '0']
- [digital_ofdm_rx_0_0, '0', blocks_uchar_to_float_0_0, '0']
- [uhd_usrp_source_0, '0', digital_ofdm_rx_0_0, '0']

metadata:
  file_format: 1
